# Keil uVision project songSTM.uvprojx, settings and files
target touch (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: songSTM +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\LIB\STM32F10x_StdPeriph_Driver\inc;..\LIB\CMSIS\CM3\CoreSupport;..\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER;..\SONG;..\GUI\Config;..\GUI\ConvertColor;..\GUI\ConvertMono;..\GUI\Core;..\GUI\Font;..\GUI\AntiAlias;..\GUI\JPEG;..\GUI\LCDDriver;..\GUI\Widget;..\GUI\WM;..\GUI\MultiLayer;..\OS\CONFIG;..\OS\CORE;..\OS\PORT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c atk_ncr.c ATKNCR_N_V2.0.lib
  group SONG
    ../SONG/: song_IO.c song_NVIC.c song_gpio_spi.c song_i2cinit.c song_spi.c song_matrix.c song_dds.c song_timer.c song_touch.c song_user_lcd.c song_usart.c song_hc05.c
  group LIB
    ../LIB/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group CMSIS
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STARTUP
    ../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group UCConfig
    ../OS/CONFIG/: includes.h os_cfg.h
  group UCCore
    ../OS/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCPort
    ../OS/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
target UCGUI (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: songSTM +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\LIB\STM32F10x_StdPeriph_Driver\inc;..\LIB\CMSIS\CM3\CoreSupport;..\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER;..\SONG;..\GUI\Config;..\GUI\ConvertColor;..\GUI\ConvertMono;..\GUI\Core;..\GUI\Font;..\GUI\Config\GUI_X;..\GUI\WM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
